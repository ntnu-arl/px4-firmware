## src/drivers/imu/lsm6ds0/Kconfig
```kconfig
menuconfig DRIVERS_IMU_LSM6DS0
	bool "lsm6ds0"
	default n
	---help---
		Enable support for st lsm6ds0
```
